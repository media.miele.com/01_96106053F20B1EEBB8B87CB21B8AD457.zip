Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-07-06T12:23:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 06 12:23:05 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{9DEB4848-E8AA-4C7F-95BF-8A3B4A7E7E3B}\ifc * Database version: 5507 * Database creation date: Tue Jul 06 12:23:03 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 06 12:23:04 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 06 12:23:04 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 28126035_IB_10552960_DA1260_BRWS, 10552960_IB_DA1260_BRWS:28126035_IB_10552960_DA1260_BRWS:207197
In: Level 1
Type - Classification: UNTERBAU DA (Uniformat); Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_BRWS, Glass, Aluminum, z_Miele_Connection_Electric, z_Miele_Connection_ExhaustAir, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - Reference: 28126035_IB_10552960_DA1260_BRWS
Pset_ManufacturerTypeInformation - Manufacturer: Miele
